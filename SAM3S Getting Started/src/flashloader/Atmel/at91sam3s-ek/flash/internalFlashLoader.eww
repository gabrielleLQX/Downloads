<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\internalFlashLoader.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>internalFlash-flashloader</name>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM7a3</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM7L128</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM7L64</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM7S128</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM7S256</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM7S32</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM7S321</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM7S512</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM7S64</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM7SE256</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM7SE32</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM7SE512</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM7x128</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM7x256</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM7x512</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM9XE128</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM9XE256</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM9XE512</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM7xc128</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM7xc256</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM7xc512</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM3U4</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM7SL16</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM7SL32</configuration>
      </member>
      <member>
        <project>internalFlashLoader</project>
        <configuration>internalFlashSAM7SL64</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


