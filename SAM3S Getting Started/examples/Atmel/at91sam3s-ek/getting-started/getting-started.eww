<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
	<project>
		<path>$WS_DIR$\ewp\getting-started.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>All</name>>
			<member>
				<project>at91sam3s-ek</project>
				<configuration>at91sam3s4_sram</configuration>
			</member>
			<member>
				<project>at91sam3s-ek</project>
				<configuration>at91sam3s4_flash</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>
