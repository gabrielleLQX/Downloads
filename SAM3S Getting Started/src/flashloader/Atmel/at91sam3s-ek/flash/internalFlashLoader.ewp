# IAR project internalFlashLoader.ewp, settings and files
configuration internalFlashSAM3S4 (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  ICCARM.CCDefines: at91sam3s4; sram; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\..\..\..\..\libraries\board\at91sam3s4; ..\..\..\..\..\..\..\libraries\board; ..\..\..\..\..\..\..\libraries\drivers; ..\framework2; ..\interface
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: internalFlashLoader.srec
  postbuild: cmd.exe /c copy $TARGET_PATH$ ..\..\..\..\..\config\flashloader\atmel\at91sam3s4-ek\
  ILINK.IlinkOutputFile: internalflash-sam3s4.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\libraries\board\at91sam3s4\sram_flashloader.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
  group (top)
    ../interface/: Interface.c
    ./: internalFlashLoader.c
  group at91lib/boards/at91sam3s-ek/at91sam3s4
    ../../../../../../../libraries/board/at91sam3s4/: AT91SAM3S4.h
    ../../../../../../../libraries/board/: board.h
  group at91lib/memories/flash
    ../../../../../../../libraries/drivers/flash/: flashd.c
  group at91lib/peripherals/eefc
    ../../../../../../../libraries/drivers/efc/: efc.c
  group at91lib/utility
    ../../../../../../../libraries/drivers/utility/: math.c
  group framework
    $EW_DIR$/arm/src/flashloader/framework2/: flash_loader.c flash_loader_asm.s
