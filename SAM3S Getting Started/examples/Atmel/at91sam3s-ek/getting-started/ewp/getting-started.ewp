# IAR project getting-started.ewp, settings and files
configuration at91sam3s4_sram (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam3s4 Atmel at91sam3s4
  ICCARM.CCDefines: at91sam3s4; sram; at91sam3s4; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\../libraries/board; ..\../libraries/drivers; ..\../libraries
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam3s4; sram; at91sam3s4; __ASSEMBLY__
  AARM.AUserIncludes: ..\..\..\libraries; ..\..\..\libraries\peripherals; ..\..\..\libraries\board\
  OBJCOPY.OOCOutputFile: at91sam3s4_sram.bin
  ILINK.IlinkOutputFile: at91sam3s4_sram.out
  ILINK.IlinkIcfFile: ..\..\libraries\board\at91sam3s4\sram
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam3s4_flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam3s4; flash; at91sam3s4; TRACE_LEVEL=4
  AARM.ADefines: at91sam3s4; flash; at91sam3s4; __ASSEMBLY__
  OBJCOPY.OOCOutputFile: at91sam3s4_flash.bin
  ILINK.IlinkOutputFile: at91sam3s4_flash.out
  ILINK.IlinkIcfFile: ..\..\libraries\board\at91sam3s4\flash
  group documentation
    $EW_DIR$/arm/examples/Atmel/at91sam3s-ek/documentation/html/: index.html
    $EW_DIR$/arm/examples/Atmel/: flashloaders.html
  group getting-started
    ../../getting-started/: main.c
  group libraries/board
    ../../libraries/board/: board.h board_cstartup_iar.c board_lowlevel.c board_lowlevel.h board_memories.h exceptions.c exceptions.h
  group libraries/board/at91sam3s4
    ../../libraries/board/at91sam3s4/: AT91SAM3S4.h
  group libraries/cmsis
    ../../libraries/cmsis/: core_cm3.h
  group libraries/drivers/pio
    ../../libraries/drivers/pio/: pio.c pio.h pio_it.c pio_it.h
  group libraries/drivers/pmc
    ../../libraries/drivers/pmc/: pmc.c pmc.h
  group libraries/drivers/usart
    ../../libraries/drivers/usart/: uart_console.c uart_console.h
  group libraries/drivers/utility
    ../../libraries/drivers/utility/: assert.h led.c led.h trace.c trace.h
  group libraries/drivers/wdt
    ../../libraries/drivers/wdt/: wdt.c wdt.h
  group resources
    ../../libraries/board/at91sam3s4/: sram.icf flash.icf
